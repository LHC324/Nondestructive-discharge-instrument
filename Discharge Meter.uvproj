# Keil uVision project Discharge Meter.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Discharge_Meter +hex
  AfterMake: "G:\STC_Workers\Nondestructive discharge instrument\hex2bin.bat"
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Inc;.\SmallRTOS\Inc
  asm include: .\SmallRTOS\Inc
  group Ams
    ./: STARTUP.A51
  group Src
    ./Src/: charger.c dwin.c gpio.c iic.C lte.c main.c ModbusMaster.c SC8913.C timer.c usart.c wifi.c eeprom.c discharger.c Modbus.c utils_ringbuffer.c ymodem.c w25qx.c spi.c
  group SmallRTOS
    ./SmallRTOS/Src/: OS_CORE.C OS_CPU_C.C OS_Q.C OS_SEM.C OS_CPU_A.ASM
